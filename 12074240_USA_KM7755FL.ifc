Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-02-06T11:38:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 06 11:38:50 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\0cf43fe8-f42b-47e4-87bb-abb6b3ce2b2d\6f517603-c05b-47bb-a637-b0f4e16092dd\ifc * Database version: 5507 * Database creation date: Tue Feb 06 11:38:49 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 06 11:38:50 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 06 11:38:50 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12074240_USA_KM7755FL:26775570_USA_12074240_KM7755FL, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 26775570_USA_12074240_KM7755FL
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 26775570_USA_12074240_KM7755FL
Pset_BuildingElementProxyCommon - sets with these values: 2
